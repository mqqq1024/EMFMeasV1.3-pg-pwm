# Keil uVision project AIP-EMFMeasV1-3-pg-pwm.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AIP-EMFMeasV1-3-pg-pwm +hex
  group src
    ../src/apps/: main.c ADC.c AT45DB041E.c coeff.c filter.c FSM.c GlobalVar.c Hall.c initialize.c measure.c Message.c power.c pwm.c relay.c Sample.c Serial.c Vsp.c
  group lib
    ../src/device/: system_stm32f10x.c startup_stm32f10x_hd.c
    ../src/lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../src/syscall/: syscall.c
